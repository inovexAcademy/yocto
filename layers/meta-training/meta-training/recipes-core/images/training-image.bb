require training-image-base.inc

