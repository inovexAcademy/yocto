require training-image-base.inc

IMAGE_INSTALL:append = " perfetto"
