FILESEXTRAPATHS:prepend:emu := "${THISDIR}/configurations:"
SRC_URI:append:emu = "file://virtio.cfg"

